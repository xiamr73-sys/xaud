# Keil uVision project FOC_Fortior_FU6832.uvproj, settings and files
target FOC_Fortior_FU6832 (MCS-51)
  device: FU6832 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FOC_Fortior_FU6832 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\include;..\FU68xx_Haidware_Driver\Include
  link misc: REMOVEUNUSED
  group Application
    ../User/source/Application/: main.c AddFunction.c Interrupt.c QEP.c
    ../User/include/: Customer.h Develop.h Protect.h
  group Function
    ../User/source/Function/: MotorControl.c MotorControlFunction.c MotorProtect.c
  group HardWare
    ../User/source/Hardware/: ADC.c AMP.c CMP.c CRC.c DMA.c DRIVER.c FLASH.c GPIO.c I2C.c PIInit.c SPI.c TIMER.c UART.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Haidware_Driver/Source/: STARTUP_FU6804.A51
  group Document
    ../Document/: DebugLog.txt
